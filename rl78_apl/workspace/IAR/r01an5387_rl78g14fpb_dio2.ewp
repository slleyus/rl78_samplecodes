# IAR project r01an5387_rl78g14fpb_dio2.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104ML RL78 - R5F104ML
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: AR_LIB; $PROJ_DIR$
  ILINK.IlinkOutputFile: r01an5387_rl78g14fpb_dio2.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group Applilet
    ./: iodefine.h r_cg_cgc.c r_cg_cgc.h r_cg_macrodriver.h r_cg_timer.c r_cg_timer.h r_cg_userdefine.h r_main.c r_systeminit.c
  group AR_LIB
    AR_LIB/: AR_LIB_PORT.c AR_LIB_PORT.h AR_LIB_TIME.c AR_LIB_TIME.h AR_SKETCH.h
  group AR_SKETCH
    sketch/: AR_SKETCH.c
