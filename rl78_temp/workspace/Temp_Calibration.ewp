# IAR project Temp_Calibration.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: applilet3_src\; fdl\pre-compiled\iar\lib\; fdl\pre-compiled\iar\smp\C\; user_src\
  ARL78.AsmIncludePath: applilet3_src\; user_src\; fdl\pre-compiled\iar\lib\; fdl\pre-compiled\iar\smp\C\
  XLINK.XlinkStackSize: 1
  XLINK.XclFile: applilet3_src\lnkr5f100le.xcl
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: R5F101LE RL78 - R5F101LE
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: applilet3_src\md_lnkr5f101le.xcl
  group applilet_src
    applilet3_src/: r_cg_adc.c r_cg_adc_user.c r_cg_cgc.c r_cg_cgc_user.c r_cg_port.c r_cg_port_user.c r_cg_rtc.c r_cg_rtc_user.c r_main.c r_systeminit.c
  group DataFlashLib
    fdl/pre-compiled/iar/lib/: fdl.r87
    fdl/pre-compiled/iar/smp/C/: fdl_descriptor.c
  group user_src
    user_src/: data_flash.c lcd.c utility.c
